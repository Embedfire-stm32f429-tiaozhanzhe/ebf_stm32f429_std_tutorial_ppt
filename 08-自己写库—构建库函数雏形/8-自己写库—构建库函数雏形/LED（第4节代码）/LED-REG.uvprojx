# Keil uVision project LED-REG.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED-REG +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\gpio;.\LED;..\LED（第4节代码）
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c startup_stm32f429_439xx.s stm32f4xx.h
    ./gpio/: stm32f4xx_gpio.c stm32f4xx_gpio.h
    ./LED/: bsp_led.c
